# Keil uVision project WifiSwitch.uvprojx, settings and files
target WifiSwitch (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WifiSwitch
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\System;.\ST_Lib\inc;.\ST_Lib\src;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./App/: main.c led.c led.h relay.c relay.h usart.c usart.h wifi.c wifi.h delay.c delay.h context.c context.h
  group ST_Lib
    ./ST_Lib/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group System
    ./System/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
